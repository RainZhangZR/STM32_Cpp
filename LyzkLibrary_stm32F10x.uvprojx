# Keil uVision project LyzkLibrary_stm32F10x.uvprojx, settings and files
target F10x (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LyzkLibrary_stm32F10x +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\FWlib\inc;.\User\inc;.\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ./FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group User
    ./User/src/: lyzkgpio.cpp LyzkUsart.cpp
    ./: main.cpp
  group Doc
    ./: GeneralDescription.txt
